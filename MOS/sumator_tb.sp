.INCLUDE C:\Users\kamie\Documents\CMOS\MOS\sumator.spi
xSUMATOR1 interface SUMATOR
